# Keil uVision project TIM3_PWM.uvprojx, settings and files
target TIM3_PWM (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM3_PWM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\FWlib\inc;..\USER;..\CMSIS;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\seek
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c timer.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_exti.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c usart3.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/seek/: seek.c
software components: CMSIS:CORE 4.2.0
